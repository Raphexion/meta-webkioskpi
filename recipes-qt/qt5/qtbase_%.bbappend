PACKAGECONFIG_append = " eglfs gles2 accessibility fontconfig linuxfb tslib"
